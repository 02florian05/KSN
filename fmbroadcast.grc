options:
  parameters:
    author: florian.seifried
    generate_options: qt_gui
    id: nbfm_rcvr
    output_language: python
    title: Armin der King
  states: {}

blocks:
- name: audio_decim
  id: variable
  parameters:
    value: '8'
  states: {}
- name: deviation
  id: variable
  parameters:
    value: '25000'
  states: {}
- name: interp
  id: variable
  parameters:
    value: '1'
  states: {}
- name: rf_decim
  id: variable
  parameters:
    value: '5'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1.92e6
  states: {}
- name: sq_lvl
  id: variable_qtgui_range
  parameters:
    label: Squelch
    start: '-100'
    step: '5'
    stop: '0'
    value: '-50'
  states: {}
- name: tuning
  id: variable_qtgui_chooser
  parameters:
    label: station
    label0: Wish 107.5
    label1: Yes FM Manila
    label2: Home Radio
    label3: 'DWRK: 96.3 Easy Rock'
    num_opts: '4'
    option0: '107500000'
    option1: '101100000'
    option2: '97900000'
    option3: '96300000'
    type: int
    value: '107500000'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    label: Volume
    start: '0'
    step: '0.05'
    stop: '1'
    value: '0.3'
  states: {}
- name: analog_fm_demod_cf_0
  id: analog_fm_demod_cf
  parameters:
    audio_decim: audio_decim
    audio_pass: '16000'
    audio_stop: '20000'
    chan_rate: samp_rate/rf_decim
    deviation: deviation
    gain: '1.0'
    tau: '75e-6'
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: sq_lvl
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: mpope
    samp_rate: '48000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '500000'
    bbdc: 'True'
    buffer_size: '16384'
    filter_source: '''Auto'''
    frequency: '107500000'
    gain1: '''fast_attack'''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: int(samp_rate)
    type: fc32
    uri: pluto.local
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '5'
    interp: '1'
    taps: ''
    type: ccc
  states: {}

connections:
- [analog_fm_demod_cf_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_simple_squelch_cc_0, '0', analog_fm_demod_cf_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [iio_pluto_source_0, '0', qtgui_sink_x_0, '0']
- [iio_pluto_source_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', analog_simple_squelch_cc_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
